# IAR project GD32303C.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F303xC GD GD32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F30X_HD
  ICCARM.CCIncludePath2: ..; ..\GD32F30x_Firmware_Library\CMSIS; ..\Utilities; ..\GD32F30x_Firmware_Library\GD32F30x_standard_peripheral\Include; ..\GD32F30x_Firmware_Library\CMSIS\GD\GD32F30x\Include; ..\Areca2\include; ..\components\console; ..\components\console\argtable3; ..\components\esp_common\include; ..\components\heap; ..\components\heap\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GD32303C.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32F303xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 4
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: GD32303C.srec
  ILINK.IlinkOutputFile: GD32303C_EVAL.out
  group Application
    ../: gd32f30x_it.c main.c systick.c
  group Areca
    ../Areca2/: abov_comms.c app_main.c control.c factory.c mqtt.c nvs_api.c thermostat_comms.c timer.c
  group Areca/dev/co2/cubic
    ../Areca2/dev/co2/cubic/: cm1106.c
  group Areca/dev/co2/winsen
    ../Areca2/dev/co2/winsen/: mhz19b.c
  group Areca/dev/dust/cubic
    ../Areca2/dev/dust/cubic/: pm2008m.c
  group Areca/dev/dust/plant
    ../Areca2/dev/dust/plant/: pms7003.c
  group Areca/dev/misc
    ../Areca2/dev/misc/: gpio_dev.c led.c remote.c serial.c
  group Areca/dev/pressure
    ../Areca2/dev/pressure/: bme680.c bsec_integration.c priv_bme680.c
  group Areca/EEP
    ../Areca2/: at24cxx.c i2c.c
  group CMSIS
    ../GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group GD32F30x_Peripherals
    ../GD32F30x_Firmware_Library/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Startup
    ../GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/IAR/: startup_gd32f30x_hd.s
